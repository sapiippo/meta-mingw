RDEPENDS_${PN}_mingw32 = "\
    nativesdk-libtool \
    "
